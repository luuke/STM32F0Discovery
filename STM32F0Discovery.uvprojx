# Keil uVision project STM32F0Discovery.uvprojx, settings and files
target STM32F0Discovery (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0Discovery
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: Main.c
  group LCD1602
    ./LCD1602/: LCD1602.c LCD1602.h
  group Delay
    ./Delay/: Delay.c Delay.h
  group ADC
    ./: ADC.c ADC.h
  group ::Device
    RTE/Device/STM32F051R8/: startup_stm32f051.s system_stm32f0xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
